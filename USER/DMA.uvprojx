# Keil uVision project DMA.uvprojx, settings and files
target DMA (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\USER;..\CORE;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\RS485;..\HARDWARE\TIMER;..\HARDWARE\CAN;..\HARDWARE\PS2;..\CAR\ENCODER;..\CAR\CRC;..\CAR\HUBMOTOR;..\CAR\STEERINGMOTOR;..\CAR\INIT;..\CAR\XIANWEI;..\HARDWARE\WDG;..\CAR\STATE;..\CAR\DEALDATE;..\CAR\CONTROL;..\CAR\ROTATIONCONTROL;..\CAR\WORKSTATE;..\HARDWARE\BEEP;..\CAR\action;..\CAR\TIMER_HUB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c config.h custom_structure.h extern_variable.h include.h variable.h
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_iwdg.c stm32f10x_wwdg.c
  group CAR
    ../CAR/ENCODER/: encoder.c encoder.h
    ../CAR/HUBMOTOR/: hubmotor.c hubmotor.h
    ../CAR/STEERINGMOTOR/: steeringmotor.c steeringmotor.h
    ../CAR/INIT/: init.c init.h
    ../CAR/XIANWEI/: xianwei.c xianwei.h
    ../CAR/DEALDATE/: dealDate.c dealDate.h
    ../CAR/CONTROL/: control.c control.h
    ../CAR/ROTATIONCONTROL/: rotationControl.c rotationControl.h
    ../CAR/WORKSTATE/: workState.c workState.h
    ../CAR/action/: action.c action.h
    ../CAR/TIMER_HUB/: timer_hub.c timer_hub.h
    ../CAR/CRC/: crc.c crc.h
    ../CAR/STATE/: state.h
  group README
    ../: README.TXT
